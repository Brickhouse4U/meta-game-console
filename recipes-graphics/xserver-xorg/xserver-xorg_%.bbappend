PACKAGECONFIG:append = " modesetting"